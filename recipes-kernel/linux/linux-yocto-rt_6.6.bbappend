require linux-yocto-bcm-2xxx-rpi.inc

KBRANCH:rpi = "v6.6/standard/preempt-rt/bcm-2xxx-rpi"
