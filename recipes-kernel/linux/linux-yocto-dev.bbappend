require linux-yocto-bcm-2xxx-rpi.inc

KBRANCH:rpi = "v6.2/standard/bcm-2xxx-rpi"

LINUX_VERSION:rpi ?= "6.2+"
