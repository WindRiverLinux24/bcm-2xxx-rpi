require linux-yocto-bcm-2xxx-rpi.inc

KBRANCH:rpi = "v5.10/standard/bcm-2xxx-rpi"

LINUX_VERSION:rpi ?= "5.10.x"
