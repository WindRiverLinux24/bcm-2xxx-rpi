require linux-yocto-bcm-2xxx-rpi.inc

KBRANCH:rpi = "v5.15/standard/bcm-2xxx-rpi"

LINUX_VERSION:rpi ?= "5.15.x"
